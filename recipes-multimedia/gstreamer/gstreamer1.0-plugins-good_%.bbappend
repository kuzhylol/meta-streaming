PACKAGECONFIG:append:raspberrypi4_64 = " rpicamsrc"
