FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://cst816x.cfg"
